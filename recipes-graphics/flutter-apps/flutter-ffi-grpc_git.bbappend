# Autoriser le réseau là où les samples en ont besoin
do_archive_pub_cache[network] = "1"
do_compile[network] = "1"



